# Keil uVision project Activity_5.uvprojx, settings and files
target Activity_5 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TemplateProject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Code
    ./: tm4c123gh6pm.s main.c display.s PortF_Init.c PortF_Init.h
    ../../../../EECE 344/Fall_23_Material/Lab_02/: tm4c123gh6pm.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
